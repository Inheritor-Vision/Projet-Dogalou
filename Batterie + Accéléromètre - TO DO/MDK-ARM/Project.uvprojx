# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-F103RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NUCLEO-F103RB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ..\Inc;..\LLDrivers\inc;..\Services;..\MyDrivers;..\Services\accelerometre;..\Services\batterie
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Application
    ../Src/: main.c
  group User Services
    ../Services/: Chrono.c
  group MyDrivers
    ../MyDrivers/: MyTimer.c
  group Drivers/STM32f1xx_LL_Driver
    ../LLDrivers/src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_adc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_usart.c
    ../LLDrivers/inc/: stm32f1xx_ll_usart.h
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
  group New Group
    ../Services/accelerometre/: acc.c acc.h
  group batterie
    ../Services/batterie/: bat.c bat.h
target Simulateur (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: NUCLEO-F103RB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
